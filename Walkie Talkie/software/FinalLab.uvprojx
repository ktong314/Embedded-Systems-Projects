# Keil uVision project FinalLab.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FinalLab
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ./
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group inc
    ./inc/: LED.c startup.s LaunchPad.c Timer0A.c PLL.c UART.c ST7735.c Unified_Port_Init.c Timer1A.c Timer2A.c ADCSWTrigger.c I2C0.c Timer4A.c
  group lib
    ./inc/: Dump.c
    ./lib/: keyboard.c mic.c speaker.c transceiver.c buttons.c
  group src
    ./: FinalLab.c
  group doc
    ./: README.md
