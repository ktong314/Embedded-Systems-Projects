# Keil uVision project Lab5.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab5
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ./
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group inc
    ./inc/: LED.c startup.s LaunchPad.c Timer0A.c PLL.c UART.c ST7735.c Unified_Port_Init.c Timer1A.c Timer1A.h Timer2A.c Timer2A.h
  group lib
    ./lib/RGB/: RGB.c
    ./lib/TLV5616/: TLV5616.c
  group src
    ./: Lab5.c Switch.c Switch.h DAC.c DAC.h Music.c Music.h
  group doc
    ./: README.md
