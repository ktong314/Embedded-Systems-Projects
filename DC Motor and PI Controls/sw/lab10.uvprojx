# Keil uVision project lab10.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab10
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..\sw
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group inc
    ./inc/: PLL.c UART.c startup.s PWM.c ST7735.c Timer0APWM.c Timer2A.c Timer0A.c Unified_Port_Init.c Timer3A.c
  group lib
    ./lib/pid_controller/: pid_controller.c pid_controller_parser.c
    ./lib/tachometer/: tachometer.c
    ./lib/: Motor.c buttons.c
  group src
    ./: lab10.c
