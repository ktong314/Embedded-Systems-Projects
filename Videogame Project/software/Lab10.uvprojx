# Keil uVision project Lab10.uvprojx, settings and files
target Lab10 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab10
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s random.s Lab10.c DAC.c ADC.c Timer0.c Timer1.c Sound.c Print.s I2C3.c SSD1306.c TExaS.c I2C1.c I2C1.h SSD1306_2.c SSD1306_2.h LED_and_Switch.c LED_and_Switch.h Timer2.c Timer2A.h
    ../inc/: CortexM.c
software components: CMSIS:CORE 5.1.2
