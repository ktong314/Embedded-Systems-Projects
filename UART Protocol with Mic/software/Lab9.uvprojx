# Keil uVision project Lab9.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab9
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..\SW
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: Lab9.c
    ./inc/: startup.s
  group lib
    ./lib/: mic.c fifo.c
    ./lib/encoder/: TX_UART.c DAC.c
    ./lib/decoder/: RX_UART.c
    ./lib/decoder/fft/: fft.c
    ./lib/encoder/tlv5616/: tlv5616.c
    ./lib/encoder/switches/: switches.c
  group inc
    ./inc/: ADCSWTrigger.c cr4_fft_256_stm32.s PLL.c ST7735.c Timer3A.c UART.c cr4_fft_64_stm32.s Timer1A.c Timer2A.c cr4_fft_1024_stm32.s Timer0A.c Unified_Port_Init.c Dump.c Timer4A.c Timer5A.c
