# Keil uVision project Lab3_4.uvprojx, settings and files
target Lab 3_4 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab3_4 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ./
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group doc
    ./: README.md
    ../: Lab03.md BLYNK.md
  group src
    ./: Lab3_4.c
  group inc
    ./inc/: startup.s PLL.c Unified_Port_Init.c UART.c Timer0A.c Timer2A.c LED.c ST7735.c esp8266_blynk.c Blynk.c speaker.c Timer3A.c
    ../../../Lab3/lab-3-som-wakdikar-kevin-tong-3/sw/inc/: Dump.c ADCSWTrigger.c
  group lib
    ./lib/RGB/: RGB.c
